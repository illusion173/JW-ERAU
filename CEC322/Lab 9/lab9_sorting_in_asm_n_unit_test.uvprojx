# Keil uVision project lab9_sorting_in_asm_n_unit_test.uvprojx, settings and files
target Application (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: lab_sorting_in_asm--main_app
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x20010000 size 0x10000
  group Source main app
    ./source/: appMain.c functions.c
  group Source test functions
    ./source/: testFunctions_all.c
  group lib_unity
    C:/pjct_arm/_lib/unity/: unity.c
target Unit test (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.8.0
  cpu: as above
  output: lab_sorting_in_asm--unit_test
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\lib;.\lib\unity
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x20010000 size 0x10000
software components: CMSIS:CORE 5.1.2, Device:Startup 1.0.1, Compiler:I/O:STDOUT 1.2.0
