# Keil uVision project F412Discovery.uvprojx, settings and files
target F412Discovery (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F412ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000-0x2003FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: lab8_statemachine_n_audio +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F412Zx
  c include: ../Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;..\..\usr_src;..\BSP;..\BSP\Common;..\BSP\wm8994
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group Application/MDK-ARM
    ./: startup_stm32f412zx.s
  group Application/User
    ../Src/: main_F412.c stm32f4xx_it.c usr_tasks.h
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_i2s.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_i2c.c stm32f4xx_hal_crc.c stm32f4xx_hal_dfsdm.c stm32f4xx_hal_uart.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_sram.c
    ../Src/: usr_tasks.h
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Usr_src
    ../Src/: usr_tasks.c
  group Driver/BSP/Components
    ../BSP/wm8994/: wm8994.c
  group Driver/BSP/STM32F412-disc
    ../BSP/: stm32412g_discovery.c
software components: CMSIS:CORE 4.3.0
